File: DPT/DPT.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: pdfvs
Parts:
- added U1: UCC21738QDWRQ1, Gate_Driver:SOIC16_DW_TEX, F.Cu at (66.4, 41.3)
